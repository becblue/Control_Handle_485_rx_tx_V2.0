# Keil uVision project sl8629V10.uvprojx, settings and files
target sl8629 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sl8629V10-20170307 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,PLATFORM=1,Rejeee
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\User\inc;..\User\inc\object;..\Lib\CMSIS\CM3\CoreSupport;..\Bsp;..\Bsp\SX1278\platform;..\Bsp\SX1278\platform\sx12xxEiger;..\Bsp\SX1278\radio;..\Bsp\SX1278;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ../User/scr/: main.c stm32f10x_it.c crc.c IOApp.c ADApp.c AOApp.c
    ../User/scr/object/: Timer.c
  group FWlib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c
  group BSP
    ../Bsp/: Bsp.c IO.c STM32_Uart1.c AD.C AO.c Key.c
    ../User/scr/: timer2.c
  group CMISIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
